require xf86-video-ati.inc

SRCREV = "99cb8c3faf1a4ce368b7500f17a2a7868c15e8e8"
PV = "7.6.1+git${SRCPV}"
