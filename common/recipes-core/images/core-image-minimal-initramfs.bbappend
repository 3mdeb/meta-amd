# This is required so extrausers functionality can be used
# with dependant images.
PACKAGE_INSTALL += "shadow"
