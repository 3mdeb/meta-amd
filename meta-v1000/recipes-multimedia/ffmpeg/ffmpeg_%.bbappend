PACKAGECONFIG_append_v1000 = " vaapi"
