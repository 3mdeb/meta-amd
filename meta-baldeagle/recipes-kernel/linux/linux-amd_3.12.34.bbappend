FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI_append_baldeagle = " file://defconfig \
"
