PR = "${INC_PR}.1"
EXTRA_OECONF_append_baldeagle = " \
		 --enable-aiglx \
		 --enable-xvmc \
		 --enable-libdrm \
		"
