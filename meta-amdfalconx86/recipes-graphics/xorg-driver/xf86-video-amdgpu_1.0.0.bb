require xf86-video-amdgpu.inc

SRCREV = "755e6ff2337cf615e3ba0854ccd533baec7144db"
PV = "1.0.0+git${SRCPV}"
