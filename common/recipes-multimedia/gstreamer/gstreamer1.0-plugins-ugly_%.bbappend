PACKAGECONFIG_append_amd = " x264"
