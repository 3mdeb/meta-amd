SRC_URI_amdgpu = "git://anongit.freedesktop.org/xorg/driver/xf86-video-amdgpu;branch=master"
SRCREV_amdgpu = "b09fde0d81e07fbe96139289098b4d4b9f5e3c35"
PV_amdgpu = "amdgpu-1.3.0"

