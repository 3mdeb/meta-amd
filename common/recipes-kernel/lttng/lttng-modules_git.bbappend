FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"
SRC_URI += "file://trace_clock_disable_preemption.patch"
