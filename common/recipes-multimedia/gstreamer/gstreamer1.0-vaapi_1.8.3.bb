require gstreamer1.0-vaapi.inc

DEPENDS += "gstreamer1.0 gstreamer1.0-plugins-base gstreamer1.0-plugins-bad"

SRC_URI[md5sum] = "727267a0a7a8dcb76b8c58cdf5ea61d4"
SRC_URI[sha256sum] = "6cf3ded097924d23df40239c8f00811d1c727aa41cdc9baaedfc2a39ff2aac0c"
