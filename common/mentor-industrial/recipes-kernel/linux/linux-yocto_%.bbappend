# use the configuration class from MEL industrial layer
inherit kernel-config-ptp
