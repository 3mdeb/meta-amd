PACKAGECONFIG_append_amd = "r600"
