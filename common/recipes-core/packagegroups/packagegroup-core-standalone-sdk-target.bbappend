RDEPENDS_${PN}_remove_amd = "\
    libgcov-dev \
    "
