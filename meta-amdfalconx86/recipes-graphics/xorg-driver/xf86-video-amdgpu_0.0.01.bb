require xf86-video-amdgpu.inc

SRCREV = "9945b4ae1664ab815b39ff07e7b66cfa7f942dfa"
PV = "0.0.01+git${SRCPV}"
