require conf/machine/include/amd-common.inc

IMAGE_INSTALL_append_snowyowl = " strongswan"
