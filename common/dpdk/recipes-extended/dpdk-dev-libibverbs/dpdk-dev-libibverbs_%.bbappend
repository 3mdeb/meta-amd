COMPATIBLE_MACHINE_snowyowl = "snowyowl"
