PR = "${INC_PR}.1"
EXTRA_OECONF_append_steppeeagle = " \
		 --enable-aiglx \
		 --enable-xvmc \
		 --enable-libdrm \
		"
