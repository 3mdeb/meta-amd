FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI_append_steppeeagle = " file://defconfig \
"
