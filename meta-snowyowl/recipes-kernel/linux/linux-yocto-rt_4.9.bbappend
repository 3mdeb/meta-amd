require linux-yocto-snowyowl_4.9.inc

KBRANCH_snowyowl ?= "standard/preempt-rt/base"
SRCREV_machine_snowyowl ?= "b6f5c933ce66e4a00412bb5c5691a2ab4187c979"
