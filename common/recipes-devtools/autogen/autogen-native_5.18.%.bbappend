FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
SRC_URI_append = " file://0001-autoopts-mk-tpl-config.sh-fix-shebang-length.patch"
