FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
SRC_URI += "file://0001-llvm-config-allow-overriding-libdir-through-cmdline.patch"
