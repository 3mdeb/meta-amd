DEPENDS_append_amd = " mesa-glut glew"
PACKAGECONFIG_append_amd = " glut"
EXTRA_OECONF_remove_amd = "--enable-glew --enable-glu"
