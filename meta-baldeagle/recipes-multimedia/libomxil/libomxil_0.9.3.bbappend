RDEPENDS_${PN} += "libomx-mesa"
