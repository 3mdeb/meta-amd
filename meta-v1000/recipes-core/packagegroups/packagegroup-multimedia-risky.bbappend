RDEPENDS_${PN}_append_v1000 = " ffmpeg"
