PACKAGECONFIG_append_amd = " v4l"
