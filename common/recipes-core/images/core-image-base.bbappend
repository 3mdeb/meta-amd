require conf/machine/include/amd-multimedia.inc
