FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"
SRC_URI_append_amd += "file://0001-playbin2-playsink-disable-video-converters-in-defaul.patch"
