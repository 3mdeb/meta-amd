FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI_append += "file://0001-fix_undefined_Fl_XFont_On_Demand.patch"
