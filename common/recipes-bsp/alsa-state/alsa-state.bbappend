# Append path to include custom asound.conf
FILESEXTRAPATHS_prepend_amd := "${THISDIR}/${PN}:"

