PACKAGECONFIG_CONFARGS += "-qt-pcre"
