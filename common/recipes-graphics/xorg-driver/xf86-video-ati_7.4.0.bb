require xf86-video-ati.inc

SRCREV = "906a0ec9224146098bb4581486129d2934d36495"
PV = "7.4.0+git${SRCPV}"
