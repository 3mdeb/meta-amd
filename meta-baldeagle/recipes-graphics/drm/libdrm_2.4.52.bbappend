EXTRA_OECONF += "--enable-optimized \
		 --disable-assertions \
		 --enable-shared \
		 --enable-targets=x86_64 \
		 --enable-experimental-targets=R600 \
		 --enable-bindings=none"
