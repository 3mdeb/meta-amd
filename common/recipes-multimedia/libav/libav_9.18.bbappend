DEPENDS_append_amd = " libvdpau"
EXTRA_OECONF_append_amd = " --enable-vdpau"
