PACKAGECONFIG_remove_amd = " gstreamer010"

