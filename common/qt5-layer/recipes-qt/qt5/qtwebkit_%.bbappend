PACKAGECONFIG_remove_amd = " gstreamer010"
PACKAGECONFIG_append_amd = " gstreamer"
