# Not yet needed here.  The right fix may be to specify which platforms
# explicitly get this patch but I need to do more due diligence first.
SRC_URI_remove_amdfalconx86 = " \
     file://Update-compaction-instrumentation-to-3.12-kernel.patch \
"
