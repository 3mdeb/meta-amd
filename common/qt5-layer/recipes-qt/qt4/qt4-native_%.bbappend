FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
SRC_URI += " file://0015-configure-add-nostrip-for-debug-packages.patch"
