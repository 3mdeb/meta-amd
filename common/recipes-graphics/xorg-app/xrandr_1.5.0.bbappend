FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += " file://0001-Fixed-CRTC-disable-in-xrandr-causing-scale-issue.patch"
