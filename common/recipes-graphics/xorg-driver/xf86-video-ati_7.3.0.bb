require recipes-graphics/xorg-driver/xf86-video-ati.inc

SRCREV = "0333f5bda27dc0ec2edc180c7a4dc9a432f13f97"
PV = "7.3.0+git${SRCPV}"
