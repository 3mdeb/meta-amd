LIBAV_EXTRA_CONFIGURE_COMMON_ARG_append_amd = " --cross-prefix='${HOST_PREFIX}' "
