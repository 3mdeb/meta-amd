IMAGE_INSTALL_append_snowyowl = " dpdk \
                                  dpdk-examples \
                                  dpdk-test"
