# We use xserver-common
VIRTUAL-RUNTIME_xserver_common_amd = "xserver-common"
