FILESPATH_prepend := "${THISDIR}/files:"
SRC_URI += "file://0001-Ensure-xcb-owns-socket-and-no-other-threads-are-writ.patch"
