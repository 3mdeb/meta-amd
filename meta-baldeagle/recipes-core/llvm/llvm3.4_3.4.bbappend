PACKAGECONFIG_append_baldeagle = "r600"
